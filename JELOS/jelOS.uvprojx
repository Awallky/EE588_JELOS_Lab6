# Keil uVision project jelOS.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jelos
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress 6238
  group Source
    ./src/: UART.c startup.s PLL.c serialio.c shell.c EdgeInterrupt.c ostestmain.c jelos.c jelosASM.s
  group Includes
    ./include/: jelos.h mylib.h PLL.h sysctl.h UART.h
